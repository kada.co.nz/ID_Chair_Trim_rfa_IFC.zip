Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2021-06-04T18:18:58
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190510_1515(x64) - Exporter 18.3.3.18 - Alternate UI 18.3.3.18
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Jun 04 18:18:58 2021 * Host: Avocado-PC * Database: D:\Jocuri\TEMP\{321A44DB-F25C-49CF-ACEB-18AF8A9B4D9D}\ifc * Database version: 5507 * Database creation date: Fri Jun 04 18:18:57 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Jun 04 18:18:57 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Jun 04 18:18:57 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFurnishingElement: ID Chair Trim - FlowMotion without forward tilt, without seat depth adjustement, Furniture_Office-Chairs_Vitra_ID-Chair_Trim:ID Chair Trim - FlowMotion without forward tilt, without seat depth adjustement:511195
In: Level 1
Type - Material: Textile laser light grey pastel green 25, Basic Dark, Chrome
Type - Construction - MekanismType_1: yes; MekanismType_2: no; MekanismType_3: no; MekanismType_4: no
Type - Dimensions - NominalDepth: 670 mm; NominalHeight: 1050 mm; NominalLength: 685.766 mm
Type - General - Author: BIMStone; BIMObjectName: Furniture_Office-Chairs_Vitra_ID-Chair_Trim; ManufacturerName: Vitra; ManufacturerURL: https://www.vitra.com/; NBSDescription: Office chairs; NBSReference: 45-35-20/330; ProductInformation: ID Trim conveys a sense of classic elegance and quality craftsmanship. The self-supporting backrest construction consists of a fabric or leather cover stretched across the frame. The multi-chamber padding creates an upholstered effect with comfortable support.; Revision: n/a; Uniclass2: Pr_40_50_12_57; Uniclass2015Description: Office chairs; Uniclass2015Reference: Pr_40_50_12_57; Version: 1; VersionDate: 02/06/2021
Type - Identity Data - Collection: ID Chair; Cost: 0; Description: ID Trim conveys a sense of classic elegance and quality craftsmanship. The self-supporting backrest construction consists of a fabric or leather cover stretched across the frame. The multi-chamber padding creates an upholstered effect with comfortable support.; Designer: Antonio Citterio; Manufacturer: Vitra; Model: ID Chair - Trim; OmniClass Number: 23.40.20.14.14.11; OmniClass Title: Chairs; Type Name: ID Chair Trim - FlowMotion without forward tilt, without seat depth adjustement; URL: https://www.vitra.com/en-us/product/id-chair-concept
Type - Other - AccessibilityPerformance: n/a; AssetType: Movable; Brand: Vitra; Category: Office chairs; CodePerformance: n/a; Color: Various; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: Furniture_Office-Chairs_Vitra_ID-Chair_Trim; Features: Adjustable lumbar support, FlowMotion mechanism, seat height adjustment; Finish: n/a; Grade: n/a; Material: Textile, aluminium, plastic; ModelNumber: n/a; ModelReference: n/a; Name: ID-Chair_Trim; ReplacementCost: n/a; Shape: Sculptured; Size: 700-940x660-795x990-1100 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: n/a; Manufacturer: Vitra
Constraints - Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm
Construction - ArmrestType_2DArmrests: no; ArmrestType_3DArmrests: no; ArmrestType_RingArmrests: no; ArmrestType_WithoutArmrests: yes; BaseOnType: no; ClotherHanger: no; MetaProperties_Armrests: Without Armrests; MetaProperties_BaseOn: Castors; MetaProperties_Mechanism: FlowMotion without forward tilt, without seat depth adjustement; MetaProperties_Seat: Standard; SeatType_Contour: no; SeatType_Standard: yes
Dimensions - Area: 1.88233 m2; Volume: 0.482128 m3
Materials and Finishes - ArmrestMaterial: Powder-coated Aluminium - Black; BackrestMaterial: Textile laser light grey pastel green 25; BaseMaterial: Basic Dark; FrameMaterial: Basic Dark; SeatMaterial: Textile laser light grey pastel green 25
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Furniture; Family: Furniture_Office-Chairs_Vitra_ID-Chair_Trim: ID Chair Trim - FlowMotion without forward tilt, without seat depth adjustement; Family and Type: Furniture_Office-Chairs_Vitra_ID-Chair_Trim: ID Chair Trim - FlowMotion without forward tilt, without seat depth adjustement; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: Furniture_Office-Chairs_Vitra_ID-Chair_Trim: ID Chair Trim - FlowMotion without forward tilt, without seat depth adjustement; Type Id: Furniture_Office-Chairs_Vitra_ID-Chair_Trim: ID Chair Trim - FlowMotion without forward tilt, without seat depth adjustement; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
